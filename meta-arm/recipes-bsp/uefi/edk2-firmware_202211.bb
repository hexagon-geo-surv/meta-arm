SRCREV_edk2           ?= "fff6d81270b57ee786ea18ad74f43149b9f03494"
SRCREV_edk2-platforms ?= "f5bca45953a6c3d9e3e98394970e08dde6ad1ced"

require edk2-firmware.inc
