SRCREV_edk2           ?= "ba91d0292e593df8528b66f99c1b0b14fadc8e16"
SRCREV_edk2-platforms ?= "7c46116b0e18b81db26db3b741ca6a7166b7f0d6"

require edk2-firmware.inc
